# IAR project RTX_CM.ewp, settings and files
configuration CM4F (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMCM4_FP.h"
  ICCARM.CCIncludePath2: ..\..\..\Config; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM4\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: RTX_CM.out
configuration CM3 (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration CM4F (ARM)
  as the first configuration, except:
configuration V8MB (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration V8MBN (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration V8MM (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration V8MMN (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration V8MMF (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
configuration V8MMFN (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
  group Core
    ../../../../Source/: os_systick.c
    ../../../Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group Handlers
    ../../../Source/IAR/: irq_armv8mbl.s irq_armv8mml.s irq_cm0.s irq_cm3.s irq_cm4f.s
